<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MP3-Player.ewp</path>
  </project>
  <batchBuild />
</workspace>
